## config/boards/shields/gamebuddy/Kconfig.defconfig
```kconfig
if SHIELD_GAMEBUDDY
            
config ZMK_KEYBOARD_NAME
    default "gamebuddy"

endif
```
